Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 6461ee71-dc5d-40d9-94a0-83bf2c6d8caf, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T10:51:39+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-R23-v01:29.5x59.2-MATTRECT-CLASSIC, REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-R23-v01:29.5x59.2-MATTRECT-CLASSIC:5949
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-CALACATTA CLASSIC-DGCF-30X60-MATTRECT-CLASSIC
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-DGCF-30X60-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: 29.5x59.2-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: 29.5x59.2-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-29.5x59.2-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; PesoLiquido: 0; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ClassificacaoFogo: 0 mm; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0.075; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaElectricaExportada: 6.77; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²; PotencialDeAquecimentoGlobalTotal: 0

# IfcCovering: REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-R23-v01:29.5x59.2-POL-CLASSIC, REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-R23-v01:29.5x59.2-POL-CLASSIC:5967
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-CALACATTA CLASSIC-DGCF-30X60-POL-CLASSIC
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-DGCF-30X60-POL-CLASSIC
Pset_CoveringCommon - Reference: 29.5x59.2-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: 29.5x59.2-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-CALACATTA_CLASSIC-DGCF CANTO DIREITO-29.5x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; PotencialDeAquecimentoGlobalTotal: 0; ItemEParcialmenteReciclado: 0.075; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
