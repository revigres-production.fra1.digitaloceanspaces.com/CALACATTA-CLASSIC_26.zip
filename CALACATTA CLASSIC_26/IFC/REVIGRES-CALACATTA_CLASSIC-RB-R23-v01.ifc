Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 2fa0b43c-d4c8-496f-bdf2-f1fb897fed64, NumberOfSaves: 223], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal], ExchangeRequirement [Architecture]
Time: 2026-06-12T10:16:23+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x118.6-MATTRECT-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x118.6-MATTRECT-CLASSIC:180178
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8x120-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x118.6-POL-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x118.6-POL-CLASSIC:180174
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X120-POL-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x44.35-MATTRECT-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x44.35-MATTRECT-CLASSIC:180181
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X45-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 10.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 45 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x44.35-POL-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x44.35-POL-CLASSIC:180180
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X45-POL-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x44.35-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 10.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 45 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x59.2-MATTRECT-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x59.2-MATTRECT-CLASSIC:180176
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X60-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x59.2-POL-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x59.2-POL-CLASSIC:180171
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X60-POL-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 8 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x88.9-MATTRECT-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x88.9-MATTRECT-CLASSIC:180177
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X90-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 10.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x88.9-POL-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-8x88.9-POL-CLASSIC:180173
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-8X90-POL-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-8x88.9-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 10.5 mm; ComprimentoNominal: 8 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-MATTRECT-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-MATTRECT-CLASSIC:180179
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-9,5X30-MATTRECT-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-MATTRECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-MATTRECT-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-9.5X29.5-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 9.5 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²

# IfcCovering: Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-POL-CLASSIC, Wall Sweep:REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-POL-CLASSIC:180175
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-CALACATTA CLASSIC-RB-9,5X30-POL-CLASSIC
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-RB-9.5x29.5-POL-CLASSIC
IFC.REVIGRES-Dados gerais-Wall Sweeps - Nome: REVIGRES-CALACATTA CLASSIC-RB-9.5X29.5-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Wall Sweeps - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Sweeps - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Sweeps - VariacaoTonalidade: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Sweeps - AlturaNominal: 9.8 mm; ComprimentoNominal: 9.5 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Sweeps - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
