Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 5f33468c-73f0-4fc1-890b-c7ff3c604d2f, NumberOfSaves: 164], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal], ExchangeRequirement [Architecture]
Time: 2026-06-12T10:31:03+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC:103479
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 301BX33V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 301BX33V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BX33V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 4; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC:103487
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3012X33V7
Type - Pset_EnvironmentalImpactIndicators - Reference: 3012X33V7
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112X33V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 4; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-MATTRECT-CLASSIC:103498
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 301BX43V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 301BX43V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BX43V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-POL-CLASSIC:103506
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3012X43V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3012X43V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112X43V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x277.8-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC:103368
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 311B213V71; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 311B213V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311B213V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC:103376
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112213V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112213V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112213V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC:103404
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 311BH83V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 311BH83V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BH83V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 105 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC:103412
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112H83V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112H83V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112H83V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 105 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-MATTRECT-CLASSIC:103440
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 311BD33V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 311BD33V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BD33V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-POL-CLASSIC:103448
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112D33V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112D33V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112D33V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-MATTRECT-CLASSIC:103386
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 311B133V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 311B133V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311B133V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-POL-CLASSIC:103394
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112133V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112133V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112133V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 98 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-59.2x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-MATTRECT-CLASSIC:103422
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 311BK73V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 311BK73V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BK73V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 105 mm; ComprimentoNominal: 90 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-POL-CLASSIC:103430
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112K73V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112K73V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112K73V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 105 mm; ComprimentoNominal: 90 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-88.9x88.9-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC:103490
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 301BX33V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 301BX33V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BX33V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 4; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC:103482
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3012X33V7
Type - Pset_EnvironmentalImpactIndicators - Reference: 3012X33V7
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112X33V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 4; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-118.6x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC:103379
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - Reference: 311B213V71; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 311B213V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311B213V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 98 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC:103371
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112213V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112213V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112213V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 98 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-29.5x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC:103415
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 311BH83V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 311BH83V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 311BH83V71; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 105 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC:103407
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA_CLASSIC-BASE-44.35x88.9-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3112H83V71
Type - Pset_EnvironmentalImpactIndicators - Reference: 3112H83V71
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3112H83V71; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 105 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
