Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 5498f979-8b2a-44f2-a17c-f0f36d1c370e, NumberOfSaves: 176], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal], ExchangeRequirement [Architecture]
Time: 2026-06-12T10:20:17+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-MATT RECT-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-MATT RECT-CLASSIC:106602
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-30x120-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-MATT RECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-POL-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-POL-CLASSIC:106609
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-30x120-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-29.5x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-MATT RECT-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-MATT RECT-CLASSIC:106544
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-30x60-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-MATT RECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-POL-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-POL-CLASSIC:106551
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-30x60-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-29.5x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-MATT RECT-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-MATT RECT-CLASSIC:106586
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-45x90-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-MATT RECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-POL-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-POL-CLASSIC:106593
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-45x90-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 45 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-44.35x88.9-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-MATT RECT-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-MATT RECT-CLASSIC:106572
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-60x120-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-MATT RECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-POL-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-POL-CLASSIC:106579
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-60x120-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-59.2x118.6-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-MATT RECT-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-MATT RECT-CLASSIC:107361
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-60x60-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-MATT RECT-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-MATT RECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-POL-CLASSIC, Floor:REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-POL-CLASSIC:107368
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DG-60x60-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-POL-CLASSIC
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 2; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA CLASSIC-DG-59.2x59.2-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
