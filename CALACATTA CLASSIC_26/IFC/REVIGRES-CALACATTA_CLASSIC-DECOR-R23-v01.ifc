Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 139d5cf7-ffd6-4f99-98b0-c2edcadab053, NumberOfSaves: 166], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal], ExchangeRequirement [Architecture]
Time: 2026-06-12T10:21:39+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC:106260
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 331B6A0W11; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 331B6A0W11
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA CLASSIC-DECOR-14X59-MATT RECT-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 331B6A0W11; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 14 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC, Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC:106268
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 33126A0W11
Type - Pset_EnvironmentalImpactIndicators - Reference: 33126A0W11
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA CLASSIC-DECOR-14X59-POL-CLASSIC
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 33126A0W11; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 14 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-59.2x118.6-POL-ROYAL GOLD, Basic Wall:REVIGRES-CALACATTA_CLASSIC-DECOR-59.2x118.6-POL-ROYAL GOLD:106292
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 3312D3W891
Type - Pset_EnvironmentalImpactIndicators - Reference: 3312D3W891
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-CALACATTA CLASSIC-DECOR-60x120-POL-ROYAL GOLD
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 3312D3W891; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - EPavimento: Não; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 7; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-CALACATTA_CLASSIC-DECOR-59.2x118.6-POL-ROYAL_GOLD; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC:106271
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DECOR-14X59-MATT RECT-CLASSIC
Type - Pset_CoveringCommon - Reference: 331B6A0W11; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 331B6A0W11
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 331B6A0W11; Acabamento: MATTRECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 14 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-MATTRECT-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC, Floor:REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC:106263
In: Level 1
Type - PredefinedType: FLOORING; Material: REVIGRES-CALACATTA CLASSIC-DECOR-14X59-POL-CLASSIC
Type - Pset_CoveringCommon - IsExternal: no; Reference: 33126A0W11
Type - Pset_EnvironmentalImpactIndicators - Reference: 33126A0W11
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Calacatta_Classic; NumeroGlobalDeItemComercial: 33126A0W11; Acabamento: POL; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/calacatta-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAsManchas: Cumpre; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 14 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 294; PotencialDeAquecimentoGlobalBiogenico: -0.832; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 19.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0345; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0114; EnergiaRecuperada: 0.0395; ConsumoDeAguaDoce: 0.181; UtilizacaoLiquidaDeAguaDoce: 0.181; ResiduosPerigososEliminados: 0.00136; ResiduosNaoPerigososEliminados: 1.72; MassaTotalDeResiduosRadioactivosEliminados: 0.000289; EnergiaElectricaExportada: 6.77; MateriaisParaRecuperacaoDeEnergia: 0.0395; MateriaisParaReciclagem: 1.21; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-CALACATTA_CLASSIC-DECOR-14x59-POL-CLASSIC; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico esmaltado; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
